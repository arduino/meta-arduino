USERADD_PARAM:${PN}:prepend = "--uid 1500 "
