CORE_IMAGE_EXTRA_INSTALL:append = " imx-gst1.0-plugin"
