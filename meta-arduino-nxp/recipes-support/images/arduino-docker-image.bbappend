# Arduino m4-proxy is only needed on portenta-x8
CORE_IMAGE_EXTRA_INSTALL:append:portenta-x8 = " m4-proxy"
